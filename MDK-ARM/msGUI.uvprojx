# Keil uVision project msGUI.uvprojx, settings and files
target msGUI (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: msGUI +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c misc: --c99 --diag-suppress 111
  c include: ..\SourceFile;..\SourceFile\App;..\SourceFile\System;..\SourceFile\System\OS;..\SourceFile\System\GUI;..\SourceFile\System\Device;..\SourceFile\System\Device\Drive;..\SourceFile\System\Device\Drive\CMSIS;..\SourceFile\System\Device\Drive\LIB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../SourceFile/App/: app.c logic.c menu.c
  group System
    ../SourceFile/System/: system.c
  group System.OS
    ../SourceFile/System/OS/: os.c
  group System.Gui
    ../SourceFile/System/GUI/: gui.c fonts.c
  group System.Device
    ../SourceFile/System/Device/: device_systick.c device.c device_lcd.c device_key.c device_timer.c device_sdram.c
  group System.Device.Drive.Cmsis
    ../SourceFile/System/Device/Drive/CMSIS/: system_stm32f4xx.c
    ../SourceFile/System/Device/Drive/CMSIS/STARTUP/: startup_stm32f429_439xx.s
  group System.Device.Drive.Lib
    ../SourceFile/System/Device/Drive/LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
software components: CMSIS:CORE 4.1.0
